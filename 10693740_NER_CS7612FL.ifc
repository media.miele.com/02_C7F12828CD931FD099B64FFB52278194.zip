Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 1ac94da4-0a7b-4309-b267-ce031fab4f0d, NumberOfSaves: 1]
File name: 0001
Time: 2025-07-16T13:17:35+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 10693740_NER_CS7612FL:27761250_NER_10693740_CS7612FL, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, Default, z_Miele_Design_CLST, z_Miele_Connection_Electric, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 378 mm; Height: 51 mm; Depth: 520 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 27761250_NER_10693740_CS7612FL; sets with these values: 2
